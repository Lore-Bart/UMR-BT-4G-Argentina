# Keil uVision project Firmware V3.uvprojx, settings and files
target Firmware V3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Firmware V3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ../Inc;                             ../Drivers/STM32F4xx_HAL_Driver/Inc;                             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                             ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008200 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_exti.c stm32f4xx_ll_rcc.c stm32f4xx_hal_rcc.c stm32f4xx_ll_dma.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_ll_utils.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_ll_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ./: mymain.c Sub_ADE.c Sub_Batteria.c Sub_BOOT.c Sub_Comandi.c Sub_CRC.c Sub_FLASH.c Sub_FRAM.c Sub_Generiche.c Sub_GSM.c Sub_Guasti.c Sub_Neutro.c Sub_NFC.c Sub_RTC.c Sub_Salvataggi.c Sub_Tampering.c Sub_UART.c Sub_UPDATE.c Sub_Database.c Sub_Test.c Sub_MySQL.c
software components: CMSIS:CORE 5.1.2
